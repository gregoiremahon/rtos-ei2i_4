# Keil uVision project test_deux_it.uvprojx, settings and files
target Target (6140000::V6.14::ARMCLANG)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TD1
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Start
    ./start/: startup_LPC17xx.s system_LPC17xx.c
  group sources
    ./: Principal.c
software components: CMSIS:CORE 5.4.0
