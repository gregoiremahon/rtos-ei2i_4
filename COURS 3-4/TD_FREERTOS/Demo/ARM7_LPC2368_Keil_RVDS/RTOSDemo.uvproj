# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo_THUMB (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1769 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: KEIL_THUMB_INTERWORK
  c include: .;..\..\Source\portable\RVDS\ARM_CM3;..\Common\include;..\..\Source\include
  asm include: ..\..\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Other
    ./: main.c myTasks.c
  group FreeRTOS
    ../../Source/: tasks.c list.c queue.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
  group start
    ./start/: keil_freertos_startup_lpc17xx40xx.s system_LPC17xx.c
