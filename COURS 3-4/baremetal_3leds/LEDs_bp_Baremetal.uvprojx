# Keil uVision project LEDs_bp_Baremetal.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LEDs_bp
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Start
    ./start/: startup_LPC17xx.s system_LPC17xx.c
  group sources
    ./: LEDs_bp.c
software components: CMSIS:CORE 5.4.0
