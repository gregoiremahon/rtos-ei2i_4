# Keil uVision project TP4.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TP4
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include;..\Demo\ARM7_LPC1769_Keil_RVDS;.\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group PROJET
    ../Demo/ARM7_LPC1769_Keil_RVDS/: main.c myTasks.c
  group FREERTOS
    ./: list.c queue.c tasks.c
    ./portable/MemMang/: heap_2.c
    ./portable/RVDS/ARM_CM3/: port.c portmacro.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
